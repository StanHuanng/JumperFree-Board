# Keil uVision project 带单片机8位全彩流水灯程序模板.uvproj, settings and files
target STC15W204S (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 带单片机8位全彩流水灯程序模板 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 Main.c
  group WS2812
    ./: ws2812.c
  group Delay
    ./: Delay.c
