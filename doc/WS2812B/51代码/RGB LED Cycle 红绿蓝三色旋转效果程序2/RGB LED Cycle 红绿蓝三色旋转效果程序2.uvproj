# Keil uVision project RGB LED Cycle 红绿蓝三色旋转效果程序2.uvproj, settings and files
target STC15W204S (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODAT2
  output: RGB LED Cycle 红绿蓝三色旋转效果程序2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 Main.c
  group WS2812
    ./: ws2812.c
  group Keypad
    ./: Keypad.c
  group Delay
    ./: Delay.c
