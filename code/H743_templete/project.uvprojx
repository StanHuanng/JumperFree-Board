# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, __STDC_LIMIT_MACROS, STM32H743xx
  c include: rt-thread\include;rt-thread\components\libc\posix\io\poll;rt-thread\libcpu\arm\common;rt-thread\components\libc\posix\io\epoll;packages\stm32h7_hal_driver-latest\Inc;rt-thread\components\drivers\include;rt-thread\components\net\utest;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\phy;board;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\stm32h7_cmsis_driver-latest\Include;libraries\HAL_Drivers;packages\stm32h7_hal_driver-latest\Inc\Legacy;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\finsh;board\ports;rt-thread\components\drivers\smp_call;libraries\HAL_Drivers\drivers\config;rt-thread\components\libc\posix\io\eventfd;packages\CMSIS-Core-latest\Include;rt-thread\components\libc\compilers\common\include;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;.;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\include;board\CubeMX_Config\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh_parse.c msh.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kerrno.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32H7-CMSIS
    packages/stm32h7_cmsis_driver-latest/Source/Templates/: system_stm32h7xx.c
    packages/stm32h7_cmsis_driver-latest/Source/Templates/arm/: startup_stm32h743xx.s
  group STM32H7-HAL
    packages/stm32h7_hal_driver-latest/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr.c stm32h7xx_hal_comp.c stm32h7xx_hal.c stm32h7xx_hal_uart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_gpio.c stm32h7xx_hal_sram.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_cryp.c
