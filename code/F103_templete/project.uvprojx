# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, RT_USING_LIBC, __RTTHREAD__, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\drivers;board\CubeMX_Config\Inc;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\drivers\config;rt-thread\components\libc\posix\io\epoll;packages\stm32f1_hal_driver-latest\Inc;rt-thread\components\drivers\include;packages\stm32f1_cmsis_driver-latest\Include;board;.;rt-thread\components\libc\posix\io\poll;libraries\HAL_Drivers;rt-thread\components\libc\compilers\common\extension;applications;rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;rt-thread\libcpu\arm\common;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\include;rt-thread\components\net\utest;packages\CMSIS-Core-latest\Include;rt-thread\components\drivers\phy;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    rt-thread/components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: kstring.c kerrno.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group STM32F1-CMSIS
    packages/stm32f1_cmsis_driver-latest/Source/Templates/: system_stm32f1xx.c
    packages/stm32f1_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f103xb.s
  group STM32F1-HAL
    packages/stm32f1_hal_driver-latest/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_crc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c
